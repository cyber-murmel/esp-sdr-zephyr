options:
  parameters:
    author: esp-sdr
    description: Waterfall and spectrum on one tab, LNA gain and RF amp on the other, at 125 kS/s; the knob tunes from 1.8 to 2.8 GHz.
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: amp_en
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'tabs@1: 0,1,1,1'
    label: RF amp
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: lna
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tabs@1: 0,0,1,1'
    label: LNA gain
    label0: 0 dB
    label1: 16 dB
    label2: 32 dB
    num_opts: '3'
    option0: '0'
    option1: '16'
    option2: '32'
    type: int
    value: '16'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 'tabs@0: 0,1,1,1'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 'tabs@0: 0,0,1,1'
    int_max: '-40'
    int_min: '-90'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amp_en
    center_freq: freq
    gain: lna
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: '"RX"'
    label1: '"Settings"'
    num_tabs: '2'
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
