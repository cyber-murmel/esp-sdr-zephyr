options:
  parameters:
    author: esp-sdr
    description: Waterfall and spectrum on one tab, the radio's gain, AGC and the FFT size on the other, at 125 kS/s; the knob tunes from 1.8 to 2.8 GHz.
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Receiver
  states: {}

blocks:
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 'tabs@1: 0,1,1,1'
    label: AGC
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tabs@1: 0,0,1,1'
    label: Gain
    label0: '16'
    label1: '32'
    label2: '48'
    num_opts: '3'
    option0: '16'
    option1: '32'
    option2: '48'
    type: int
    value: '48'
    widget: radio_buttons
  states: {}
- name: fft
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'tabs@1: 1,0,1,2'
    label: FFT
    label0: '256'
    label1: '512'
    label2: '1024'
    label3: '2048'
    label4: '4096'
    num_opts: '5'
    option0: '256'
    option1: '512'
    option2: '1024'
    option3: '2048'
    option4: '4096'
    type: int
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft
    grid: 'True'
    gui_hint: 'tabs@0: 0,1,1,1'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft
    grid: 'True'
    gui_hint: 'tabs@0: 0,0,1,1'
    int_max: '-60'
    int_min: '-90'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: agc
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: '"RX"'
    label1: '"Settings"'
    num_tabs: '2'
  states: {}
- name: fft_reaches_the_sinks
  id: snippet
  parameters:
    code: |-
      for sink in (self.qtgui_waterfall_sink_x_0, self.qtgui_freq_sink_x_0):
          self._fft_combo_box.currentIndexChanged.connect(lambda i, s=sink: s.set_fft_size(self._fft_options[i]))
    comment: GRC has no callback for FFT size.
    section: main_after_init
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
