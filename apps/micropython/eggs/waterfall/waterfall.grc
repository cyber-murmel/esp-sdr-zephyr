options:
  parameters:
    author: esp-sdr
    description: 'A gapless waterfall of 250 kHz to 2 MHz (a chooser, up to the board''s top rate: 2 MS/s on the WHY2025 badge, 500 kS/s on the S3), or of 80 MHz: without a gap where the radio streams it (the WHY2025 badge: the bursts its channelizer finds, each at its channel, over quiet noise), else from bursts at 80 MS/s, or of 40 MHz from bursts; the knob tunes from 1.8 to 2.8 GHz and sets the radio''s gain (or leaves it to AGC) and the lower and upper levels of the colour scale (at 40 and 80 MHz the lower 3 dB lower, the upper 22 dB higher).'
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Waterfall
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '48'
  states: {}
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,1,1,1
    label: AGC
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: lower
  id: variable_qtgui_range
  parameters:
    label: Lower dB
    start: '-110'
    step: '1'
    stop: '-20'
    value: '-77'
  states: {}
- name: upper
  id: variable_qtgui_range
  parameters:
    label: Upper dB
    start: '-100'
    step: '1'
    stop: '-10'
    value: '-57'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    labels: '["250 kS/s", "500 kS/s", "1 MS/s", "2 MS/s", "40 MS/s", "80 MS/s"]'
    num_opts: '0'
    options: '[250e3, 500e3, 1e6, 2e6, 40e6, 80e6]'
    type: real
    value: 250e3
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '256'
    grid: 'True'
    int_max: upper + (22 if samp_rate > 10e6 else 0)
    int_min: lower - (3 if samp_rate > 10e6 else 0)
    name: '"Waterfall"'
    type: complex
    update_time: '0.02'
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: agc
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
