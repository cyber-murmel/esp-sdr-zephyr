options:
  parameters:
    author: esp-sdr
    description: 'A gapless waterfall of 250 kHz to 2 MHz (a chooser, up to the board''s top rate: 2 MS/s on the WHY2025 badge, 500 kS/s on the S3), or of 80 MHz: without a gap where the radio streams it (the WHY2025 badge: the bursts its channelizer finds, each at its channel, over quiet noise), else from bursts at 80 MS/s; the knob tunes from 1.8 to 2.8 GHz and sets the lower and upper levels of the colour scale (at 80 MHz the lower 3 dB lower, the upper 22 dB higher).'
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Waterfall
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: lower
  id: variable_qtgui_range
  parameters:
    label: Lower dB
    start: '-110'
    step: '1'
    stop: '-20'
    value: '-77'
  states: {}
- name: upper
  id: variable_qtgui_range
  parameters:
    label: Upper dB
    start: '-100'
    step: '1'
    stop: '-10'
    value: '-57'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample rate
    label0: 2 MS/s
    label1: 1 MS/s
    label2: 500 kS/s
    label3: 250 kS/s
    label4: 80 MS/s
    num_opts: '5'
    option0: 2e6
    option1: 1e6
    option2: 500e3
    option3: 250e3
    option4: 80e6
    type: real
    value: 250e3
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '256'
    int_max: upper + (22 if samp_rate > 10e6 else 0)
    int_min: lower - (3 if samp_rate > 10e6 else 0)
    name: '"Waterfall"'
    type: complex
    update_time: '0.02'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
