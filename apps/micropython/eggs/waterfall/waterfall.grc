options:
  parameters:
    author: esp-sdr
    description: A gapless waterfall of 250 kHz; the knob tunes from 1.8 to 2.8 GHz and sets the level (the top of the colour scale).
    generate_options: qt_gui
    id: waterfall
    title: Waterfall
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    stop: 2.8e9
    step: 1e6
    value: 2.44e9
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    label: Level dB
    start: '-100'
    stop: '-20'
    step: '1'
    value: '-57'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    samp_rate: samp_rate
    center_freq: freq
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    fftsize: '256'
    fc: freq
    bw: samp_rate
    name: '"250 kS/s"'
    update_time: '0.02'
    int_min: level - 20
    int_max: level
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
