options:
  parameters:
    author: esp-sdr
    description: 'Spectrum, waterfall and samples of 250 kHz to 2 MHz (a chooser, up to the board''s top rate: 2 MS/s on the WHY2025 badge, 500 kS/s on the S3), or of 40 or 80 MHz: without a gap where the radio streams it (the WHY2025 badge: the bursts its channelizer finds, each at its channel, over quiet noise), else from bursts; the knob tunes from 1.8 to 2.8 GHz and sets the radio''s gain (or leaves it to AGC) and the FFT size.'
    generate_options: qt_gui
    id: spectrum
    output_language: python
    title: Spectrum
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '48'
  states: {}
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,1,1,1
    label: AGC
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: fft
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: FFT
    label0: '256'
    label1: '512'
    label2: '1024'
    label3: '2048'
    label4: '4096'
    num_opts: '5'
    option0: '256'
    option1: '512'
    option2: '1024'
    option3: '2048'
    option4: '4096'
    type: int
    value: '1024'
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,1
    label: Rate
    labels: '["250 kS/s", "500 kS/s", "1 MS/s", "2 MS/s", "40 MS/s", "80 MS/s"]'
    num_opts: '0'
    options: '[250e3, 500e3, 1e6, 2e6, 40e6, 80e6]'
    type: real
    value: 250e3
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft
    grid: 'True'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Samples"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft
    grid: 'True'
    int_max: '-60 + (40 if samp_rate > 10e6 else 0)'
    int_min: '-90 + (25 if samp_rate > 10e6 else 0)'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: agc
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: fft_reaches_the_sinks
  id: snippet
  parameters:
    code: |-
      for sink in (self.qtgui_waterfall_sink_x_0, self.qtgui_freq_sink_x_0):
          self._fft_combo_box.currentIndexChanged.connect(lambda i, s=sink: s.set_fft_size(self._fft_options[i]))
    comment: GRC has no callback for FFT size.
    section: main_after_init
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
