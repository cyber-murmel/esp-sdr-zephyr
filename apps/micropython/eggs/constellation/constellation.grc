options:
  parameters:
    author: esp-sdr
    description: The received samples as a constellation, next to their spectrum, at 250 kS/s; the knob tunes from 1.8 to 2.8 GHz.
    generate_options: qt_gui
    id: constellation
    title: Constellation
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    stop: 2.8e9
    step: 1e6
    value: 2.44e9
    gui_hint: 0,0,1,2
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    samp_rate: samp_rate
    center_freq: freq
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    type: complex
    size: '1024'
    name: '"IQ"'
    ymin: '-0.5'
    ymax: '0.5'
    xmin: '-0.5'
    xmax: '0.5'
    gui_hint: 1,0,1,1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    fftsize: '1024'
    fc: freq
    bw: samp_rate
    name: '"Spectrum"'
    ymin: '-120'
    ymax: '0'
    gui_hint: 1,1,1,1
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
