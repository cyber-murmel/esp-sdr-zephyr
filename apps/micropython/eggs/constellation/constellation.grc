options:
  parameters:
    author: esp-sdr
    description: The received samples as a constellation, next to their spectrum, at 250 kS/s; the knob tunes from 1.8 to 2.8 GHz.
    generate_options: qt_gui
    id: constellation
    output_language: python
    title: Constellation
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    name: '"IQ"'
    size: '1024'
    type: complex
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
