options:
  parameters:
    author: esp-sdr
    description: The received samples as a constellation, next to their spectrum, at 250 kS/s; the knob tunes from 1.8 to 2.8 GHz and sets the radio's gain (or leaves it to AGC) and the FFT size.
    generate_options: qt_gui
    id: constellation
    output_language: python
    title: Constellation
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Gain
    start: '0'
    step: '1'
    stop: '73'
    value: '48'
  states: {}
- name: agc
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 1,1,1,1
    label: AGC
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: fft
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,2
    label: FFT
    label0: '256'
    label1: '512'
    label2: '1024'
    label3: '2048'
    label4: '4096'
    num_opts: '5'
    option0: '256'
    option1: '512'
    option2: '1024'
    option3: '2048'
    option4: '4096'
    type: int
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,0,1,1
    name: '"IQ"'
    size: '1024'
    type: complex
    xmax: '0.5'
    xmin: '-0.5'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: fft
    grid: 'True'
    gui_hint: 3,1,1,1
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: soapy_plutosdr_source_0
  id: soapy_plutosdr_source
  parameters:
    agc: agc
    bandwidth: '0'
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: fft_reaches_the_sinks
  id: snippet
  parameters:
    code: |-
      for sink in (self.qtgui_freq_sink_x_0,):
          self._fft_combo_box.currentIndexChanged.connect(lambda i, s=sink: s.set_fft_size(self._fft_options[i]))
    comment: GRC has no callback for FFT size.
    section: main_after_init
  states: {}

connections:
- [soapy_plutosdr_source_0, '0', qtgui_const_sink_x_0, '0']
- [soapy_plutosdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
