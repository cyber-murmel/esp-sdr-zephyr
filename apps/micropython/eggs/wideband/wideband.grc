options:
  parameters:
    author: esp-sdr
    description: 'A waterfall of 80 MHz without a gap where the radio streams it (the WHY2025 badge: the bursts its channelizer finds, each at its channel, over quiet noise), else from bursts at 80 MS/s; the knob tunes from 1.8 to 2.8 GHz and sets the level (the top of the colour scale).'
    generate_options: qt_gui
    id: wideband
    output_language: python
    title: Wideband
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: 1.8e9
    step: 1e6
    stop: 2.8e9
    value: 2.44e9
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    label: Level dB
    start: '-80'
    step: '1'
    stop: '0'
    value: '-35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    int_max: level
    int_min: level - 45
    name: '"80 MS/s"'
    type: complex
    update_time: '0.02'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
